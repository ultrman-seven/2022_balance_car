# Keil uVision project car_3277.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F3277G9P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.5
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: car_3277
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS;.\src;.\MM32F327x\Include;.\MM32F327x\HAL_Lib\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group START
    ./MM32F327x/Source/: system_mm32f327x.c startup_mm32f327x_keil.s
  group HAL
    ./MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group USER
    ./src/: main.c common.c camera.c uart.c wy_exti.c communicate.c pictureOption.c SEEKFREE_IPS114_SPI.c
