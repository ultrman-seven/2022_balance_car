# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F3277G9P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.5
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __cplusplus
  c misc: --cpp11
  c include: ../CMSIS;../MM32F327x;../MM32F327x/HAL_Lib;../MM32F327x/HAL_Lib/Inc;../MM32F327x/HAL_Lib/Src;../MM32F327x/Include;../MM32F327x/Source;../WyCppHal;../WyCppHal/inc;../WyCppHal/src;../WyLib;../WyLib/CAMERA;../WyLib/FLASH;../WyLib/LED;../WyLib/MENU;../WyLib/MOTOR;../WyLib/OLED;./;./src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group MM_HAL
    ../MM32F327x/HAL_lib/Src/: hal_adc.cpp hal_bkp.cpp hal_can.cpp hal_comp.cpp hal_crc.cpp hal_crs.cpp hal_dac.cpp hal_dbg.cpp hal_dma.cpp hal_eth.cpp hal_exti.cpp hal_flash.cpp hal_fsmc.cpp hal_gpio.cpp hal_i2c.cpp hal_iwdg.cpp hal_misc.cpp hal_pwr.cpp hal_rcc.cpp hal_rtc.cpp hal_sdio.cpp hal_spi.cpp hal_tim.cpp hal_uart.cpp hal_uid.cpp hal_ver.cpp hal_wwdg.cpp
  group START_UP
    ../MM32F327x/Source/: system_mm32f327x.cpp startup_mm32f327x_keil.s
  group WY_HAL
    ../WyCppHal/src/: common.cpp generalOutput.cpp wy_dma.cpp wy_gpio.cpp wy_iic.cpp wy_key.cpp wy_nvic.cpp wy_spi.cpp wy_tim.cpp wy_uart.cpp
  group WY_Hardware
    ../WyLib/FLASH/: w25q64.cpp
    ../WyLib/MENU/: wy_menu.cpp
    ../WyLib/MOTOR/: stepMotor.cpp
    ../WyLib/OLED/: font.cpp genScreen.cpp ips.cpp oled.cpp
  group USER
    .././project/src//: generalInit.cpp main.cpp
    ./src/: SEEKFREE_IPS114_SPI.cpp camera.cpp pictureOption.cpp communicate.cpp
