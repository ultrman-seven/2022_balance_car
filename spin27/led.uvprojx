# Keil uVision project led.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32SPIN27PS MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.5
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: led
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: MPU6050 EMPL_MM32SPIN27_WY_LIB
  c include: .\src;.\CMSIS\KEIL_CORE;.\MM32SPIN2xx_p_LIB\Include;.\MM32SPIN2xx_p_LIB\HAL_lib\inc;.\src\oled;.\src\iic;.\src\camera;.\src\hardware;.\src\menu;.\src\motor;.\src\mpu6050;.\src\mpu6050\eMPL5;.\src\storage
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group StartUp
    ./MM32SPIN2xx_p_LIB/Source/: system_MM32SPIN2xx_p.c
    ./MM32SPIN2xx_p_LIB/Source/KEIL_StartAsm/: startup_MM32SPIN2xx_p.s
  group HAL_lib
    ./MM32SPIN2xx_p_LIB/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group USR
    ./src/: common.c main.c quickSin.c wy_exti.c getImgVal.c
    ./src/oled/: font.c oled.c oledOutput.c
    ./src/mpu6050/: MPU6050.c filter.c
    ./src/motor/: encoder.c motor.c control.c motorMenu.c pid.c paraMenu.c
    ./src/menu/: key.c menu.c menuContents.c menuStack.c allVariable.c
    ./src/iic/: iic_soft.c
    ./src/hardware/: battery.c beep.c uart.c CH9141.c
    ./src/camera/: camera.c
    ./src/storage/: falsh.c
  group eMPL
    ./src/mpu6050/eMPL5/: inv_mpu.c inv_mpu_dmp_motion_driver.c
